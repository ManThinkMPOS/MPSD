<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\EV306\EV306_SENSOR.ewp</path>
    </project>
    <batchBuild />
</workspace>
