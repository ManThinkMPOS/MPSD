# IAR project EV306_SENSOR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL17Z64xxx4 NXP MKL17Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _UP_GRADE; _MPOS_RAMLOAD_LIB; _DEBUGING
  ICCARM.CCIncludePath2: ..\..\include\core; ..\..\include\driver; ..\..\include; ..\..\include\system; Driver; APP; ; Driver\SHT20; Driver\LIS2DH12; Driver\DS18B20
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EV306_SENSOR.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: MKL17Z64xxx4_MT.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\MPSD_LWS402litelib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: MKL17Z64xxx4_RDIx01.icf MyGlobal.c mymain.c
  group APP
    APP/: MyAPP.c MyApp_INT.c MyApp_LWS.c MyBoard.c MyParse.c MyTask.c MyType.h
  group Driver
    Driver/: MT_KL17_I2C.c
  group Driver/DS18B20
    Driver/DS18B20/: DS18B20.c DS18B20.h
  group Driver/LIS2DH12
    Driver/LIS2DH12/: LIS2DH12.c LIS2DH12.h lis2dh12_reg.c lis2dh12_reg.h
  group Driver/SHT20
    Driver/SHT20/: SHT20.c SHT20.h
